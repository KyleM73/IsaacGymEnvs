Commit message: working test but with train glitches

File: assets/urdf/bumpybot.urdf (robot description, URDF)
Before this commit: robot bumpybot, 2 links, 1 joints
Links:
- link base: geometry collision cylinder length=0.6318758 radius=0.3048; visual cylinder length=0.6318758 radius=0.3048
